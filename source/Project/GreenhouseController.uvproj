# Keil uVision project GreenhouseController.uvproj, settings and files
target GreenhouseController (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: GreenhouseController +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CMSIS;..\Lib\inc;..\Lib\src;..\Startup;..\User;..\FreeRTOS\inc;..\Driver
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: stm32f10x_it.c sys.c Business.c tft.c HumiTemp.c key.c Motor.c main.c WatchDog.c Font.c LightCounter.c Usart1.c RealTimeClock.c InterFlash.c Buzzer.c AnalogDigitalConverter.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c hw_config.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ../Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Startup
    ../Startup/: startup_stm32f10x_md.s
  group FreeRTOS
    ../FreeRTOS/src/: croutine.c event_groups.c heap_2.c list.c port.c queue.c tasks.c timers.c
  group Driver
    ../Driver/: DHT11.c Timer.c bsp_sdio_sd.c
  group New Group
    ../User/fatfs/: diskio.c ff.c ff.h
